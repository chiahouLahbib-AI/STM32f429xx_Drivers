# Keil uVision project STM32f429xx_GPIO_Driver.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32f429xx_GPIO_Driver
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User Application
    ./: main.c
  group User Libraries
    ./: HAL_GPIO_Driver.h HAL_TIM.h HAL_USART.h HAL_RCC.h
  group User Sources
    ./: HAL_GPIO_Driver.c HAL_TIM.c HAL_USART.c HAL_RCC.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
